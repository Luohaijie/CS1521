# Keil uVision project cs1521.uvproj, settings and files
target CS1521 (MCS-51)
  device: CS1521 AiP MCU
  cpu: IRAM(0-0xFF) CLOCK(32000000) MODC2 MDU_R515
  output: cs1521 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
    ./source/: adc.c cacul.c config.c flash.c function.c main.c timer.c uart.c
